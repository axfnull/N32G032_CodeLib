# IAR project CoreMark_Proj.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: N32G032R8 Nations N32G032R8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: N32G032; USE_STDPERIPH_DRIVER; SYSCLK_SRC=SYSCLK_USE_HSE_PLL
  ICCARM.CCIncludePath2: ..\inc; ..\coremark; ..\..\..\..\..\..\firmware\CMSIS\core; ..\..\..\..\..\..\firmware\CMSIS\device; ..\..\..\..\..\..\firmware\n32g032_std_periph_driver\inc; D:\WorkSpace\N_WorkSpace\NS3603-2A\Nationstech.N32G032_Library.2.0.0\projects\n32g032_EVAL\examples\COREMARK\CoreMark\EWARM
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CoreMark_Proj.bin
  ILINK.IlinkOutputFile: CoreMark_Proj.out
  ILINK.IlinkIcfFile: D:\WorkSpace\N_WorkSpace\NS3603-2A\Nationstech.N32G032_Library.2.0.0\projects\n32g032_EVAL\examples\COREMARK\CoreMark\EWARM\N32G032x6.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g032.c
  group COREMARK
    ../coremark/: core_list_join.c core_main.c core_matrix.c core_portme.c core_state.c core_util.c
  group DOC
    ../src/: readme.txt
  group FWLB
    ../../../../../../firmware/n32g032_std_periph_driver/src/: misc.c n32g032_crc.c n32g032_flash.c n32g032_gpio.c n32g032_rcc.c n32g032_usart.c
  group STARTUP
    ../startup/: startup_n32g032_EWARM.s
  group USER
    ../src/: main.c n32g032_it.c
