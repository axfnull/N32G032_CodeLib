# IAR project FreeRTOS_LowPower_Proj.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: N32G032R8 Nations N32G032R8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: N32G032; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\..\firmware\CMSIS\core; ..\..\..\..\..\..\firmware\CMSIS\device; ..\..\..\..\..\..\firmware\n32g032_std_periph_driver\inc; ..\..\..\..\..\..\middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\..\..\..\..\..\middlewares\Third_Party\FreeRTOS\Source\include; ..\..\..\..\..\..\middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM0
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\inc
  OBJCOPY.OOCOutputFile: FreeRTOS_LowPower_Proj.bin
  ILINK.IlinkOutputFile: FreeRTOS_LowPower_Proj.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\Nations\N32G032\N32G032x8.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g032.c
  group DOC
    ../src/: readme.txt
  group FreeRTOS
    ../../../../../../middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../../../../../middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../middlewares/Third_Party/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
    ../../../../../../middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM0/: port.c portasm.s
  group FWLB
    ../../../../../../firmware/n32g032_std_periph_driver/src/: misc.c n32g032_flash.c n32g032_gpio.c n32g032_pwr.c n32g032_rcc.c n32g032_usart.c
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32g032_EWARM.S
  group USER
    ../src/: main.c n32g032_it.c
