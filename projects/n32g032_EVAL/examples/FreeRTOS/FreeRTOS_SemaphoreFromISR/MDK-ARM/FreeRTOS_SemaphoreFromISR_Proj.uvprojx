# Keil uVision project FreeRTOS_SemaphoreFromISR_Proj.uvprojx, settings and files
target N32G032 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: N32G032R8L7 Nationstech
  pack: Nationstech.N32G032_DFP.0.1.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: FreeRTOS_SemaphoreFromISR_Proj +hex
  AfterMake: fromelf --bin --output=.\bin\FreeRTOS_SemaphoreFromISR_Proj.bin .\Objects\FreeRTOS_SemaphoreFromISR_Proj.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 wLevel=2
  c define: N32G032, USE_STDPERIPH_DRIVER
  c include: ..\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\n32g032_std_periph_driver\inc;..\..\..\..\..\..\middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM0;..\..\..\..\..\..\middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS;..\..\..\..\..\..\middlewares\Third_Party\FreeRTOS\Source\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32g032.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g032.c
  group FWLB
    ../../../../../../firmware/n32g032_std_periph_driver/src/: misc.c n32g032_flash.c n32g032_gpio.c n32g032_rcc.c n32g032_usart.c n32g032_exti.c
  group middlewares\Third_Party\FreeRTOS\Source
    ../../../../../../middlewares/Third_Party/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
  group middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS
    ../../../../../../middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM0
    ../../../../../../middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM0/: port.c
  group middlewares\Third_Party\FreeRTOS\Source\portable\MemMang
    ../../../../../../middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group USER
    ../src/: main.c n32g032_it.c
  group DOC
    ../: readme.txt
