# Keil uVision project ALGO_Demo.uvprojx, settings and files
target N32G032 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: N32G032R8L7 Nationstech
  pack: Nationstech.N32G032_DFP.0.1.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ALGO_Demo +hex
  AfterMake: fromelf --bin --output=.\bin\ALGO_Demo.bin .\Objects\ALGO_Demo.axf
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32G032, USE_STDPERIPH_DRIVER
  c include: ..\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\n32g032_std_periph_driver\inc;..\..\..\..\bsp\inc;..\..\..\..\..\..\firmware\n32g032_algo_lib\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32g032.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g032.c
  group FWLB
    ../../../../../../firmware/n32g032_std_periph_driver/src/: misc.c n32g032_gpio.c n32g032_rcc.c n32g032_usart.c
  group USER
    ../src/: main.c n32g032_it.c
  group BSP
    ../../../../bsp/src/: log.c
  group ALGO
    ../../../../../../firmware/n32g032_algo_lib/lib/: n32g032_aes.lib n32g032_algo_common.lib n32g032_rng.lib n32g032_sm4.lib
