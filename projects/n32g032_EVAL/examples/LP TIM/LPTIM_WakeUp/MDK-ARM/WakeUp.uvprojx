# Keil uVision project WakeUp.uvprojx, settings and files
target N32G032 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: N32G032K6L7 Nationstech
  pack: Nationstech.N32G032_DFP.0.1.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: WKUP +hex
  AfterMake: fromelf --bin --output=.\bin\WKUP.bin .\Objects\WKUP.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32G032, USE_STDPERIPH_DRIVER
  c include: ..\..\..\..\..\..\firmware\CMSIS\device;..\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\n32g032_std_periph_driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32g032.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g032.c
  group USER
    ../src/: main.c n32g032_it.c
  group DOC
    ../: readme.txt
  group FWLB
    ../../../../../../firmware/n32g032_std_periph_driver/src/: n32g032_flash.c n32g032_gpio.c n32g032_lptim.c n32g032_rcc.c misc.c n32g032_exti.c n32g032_dbg.c n32g032_pwr.c
