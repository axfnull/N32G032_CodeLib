# Keil uVision project CompOut.uvprojx, settings and files
target N32G032 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: N32G032R8L7 Nationstech
  pack: Nationstech.N32G032_DFP.0.1.3
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: CompOut_Project
  AfterMake: fromelf --bin --output=.\bin\CompOut_Project.bin .\Objects\CompOut_Project.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32G032, USE_STDPERIPH_DRIVER
  c include: ..\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\n32g032_std_periph_driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32g032.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g032.c
  group FWLB
    ../../../../../../firmware/n32g032_std_periph_driver/src/: misc.c n32g032_comp.c n32g032_dbg.c n32g032_exti.c n32g032_gpio.c n32g032_rcc.c n32g032_tim.c n32g032_usart.c n32g032_adc.c n32g032_can.c n32g032_crc.c n32g032_dma.c n32g032_flash.c n32g032_i2c.c n32g032_iwdg.c n32g032_lptim.c n32g032_lpuart.c n32g032_opamp.c n32g032_pwr.c n32g032_rtc.c n32g032_spi.c n32g032_tsc.c n32g032_wwdg.c
  group USER
    ../src/: main.c n32g032_it.c
  group DOC
    ../: readme.txt
