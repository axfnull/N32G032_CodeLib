# Keil uVision project Alarm.uvprojx, settings and files
target N32G032 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: N32G032K6L7 Nationstech
  pack: Nationstech.N32G032_DFP.0.1.2
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Alarm +hex
  AfterMake: fromelf --bin --output=.\bin\Alarm.bin .\Objects\Alarm.axf
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32G032, USE_STDPERIPH_DRIVER,
  c include: ..\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\n32g032_std_periph_driver\inc;..\..\..\..\bsp\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32g032.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g032.c
  group FWLB
    ../../../../../../firmware/n32g032_std_periph_driver/src/: misc.c n32g032_gpio.c n32g032_rcc.c n32g032_rtc.c n32g032_usart.c n32g032_exti.c
  group USER
    ../src/: main.c n32g032_it.c
  group DOC
    ../: readme.txt
  group LOG
    ../../../../bsp/src/: log.c
