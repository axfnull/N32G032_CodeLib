<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Normal_Master_CAN.ewp</path>
  </project>
  <batchBuild/>
</workspace>


