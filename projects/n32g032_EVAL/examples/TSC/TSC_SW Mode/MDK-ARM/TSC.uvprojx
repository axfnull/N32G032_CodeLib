# Keil uVision project TSC.uvprojx, settings and files
target N32G032 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: N32G032R8L7 Nationstech
  pack: Nationstech.N32G032_DFP.0.1.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: TSC_SW +hex
  AfterMake: fromelf --bin --output=.\bin\TSC_SW.bin .\Objects\TSC_SW.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32G032, USE_STDPERIPH_DRIVER, USE_FULL_ASSERT
  c include: ..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\n32g032_std_periph_driver\inc;..\..\..\..\bsp\inc;..\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Startup
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32g032.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g032.c
  group User
    ../src/: main.c delay.c
  group Bsp
    ../src/: bsp_it.c bsp_usart.c bsp_gpio.c bsp_timer.c bsp_tsc.c
  group Drive
    ../../../../../../firmware/n32g032_std_periph_driver/src/: misc.c n32g032_flash.c n32g032_gpio.c n32g032_lpuart.c n32g032_rcc.c n32g032_tim.c n32g032_tsc.c
  group DOC
    ../: readme.txt
